# IAR project Backup of LED.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x1c0
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x99
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.newCCIncludePaths: ./; $PROJ_DIR$
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  prebuild: D:\Work\IAR\Solar_test\build_counter.exe
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x1a0
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCNearHeapSize: 0x80
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm164pa.xcl
configuration Atmega164PA_Debug (AVR, debug)
  as the first configuration, except:
  General.SCCStackSize: 0x100
  General.SCRStackSize: 20
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCNearHeapSize: 0x90
  ICCAVR.CCDefines: NDEBUG; WATCHDOG_ENABLE
  prebuild: build_counter.exe
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm164pa.xcl
configuration Atmega164PA_Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x100
  General.SCRStackSize: 20
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCNearHeapSize: 0x90
  ICCAVR.CCDefines: NDEBUG; WATCHDOG_ENABLE
  ICCAVR.newCCIncludePaths: $PROJ_DIR$
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm164pa.xcl
configuration ATmega324P_Debug (AVR, debug)
  as the first configuration, except:
  General.SCCStackSize: 0x100
  General.SCRStackSize: 20
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCNearHeapSize: 0x100
  prebuild: build_counter.exe
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm324p.xcl
configuration Test (AVR, debug)
  as the first configuration, except:
  General.SCCStackSize: 0x120
  General.SCRStackSize: 20
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCNearHeapSize: 0x90
  ICCAVR.CCDefines: NDEBUG; xWATCHDOG_ENABLE
  prebuild: build_counter.exe
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm324p.xcl
  group APP/EBIO_APP
    APP/EBIO/: DacAdc.cpp DacAdc.h
    ./: EBIOApplication.cpp EBIOApplication.h TerminalAdaptor.h
  group APP/TEST_APP/CLCD
    ./: testCLCDApplication.cpp testCLCDApplication.h
  group APP/TEST_APP/LED
    ./: testLEDApplication.cpp testLEDApplication.h
  group APP/TEST_APP/SERIAL
    ./: testSerialApplication.cpp testSerialApplication.h
  group APP/USER_APP
    ./: userApplication.cpp userApplication.h
  group AVR_Driver
    ./: avr_common.cpp avr_common.h avr_nv_ram.cpp avr_sleep.cpp avr_spi.cpp avr_spi.h avr_timer.cpp avr_timer.h avr_uart.cpp avr_uart.h avr_WatchDog.cpp avr_WatchDog.h
  group Basic_Component
    ./: adc.cpp BCComponentManager.cpp BCComponentManager.h DInTimerAdaptor.h dio.cpp dio.h led.cpp led.h Power_Manager.cpp serialIO.cpp serialIO.h StdConsole.cpp TimerManager.cpp TimerManager.h
  group Common
    ./: build_count.h ringbuffer.cpp ringbuffer.h shared_ptr.h type.cpp type.h util.h
  group Configuration
    ./: EBIODriverFactory.cpp
  group doc
    ./: gpl-3.0.txt README.TXT
  group Driver_Interface
    ./: DriverFactory.cpp DriverFactory.h ISpi.h
  group Drivers
    ./: clcd.cpp clcd.h dac7512.cpp dac7512.h mcp3204.cpp mcp3204.h
  group EBIO_BSP_V1_0
    ./: clcd_adaptor.cpp clcd_adaptor.h dac7512_adaptor.cpp dac7512_adaptor.h dio_adaptor.cpp dio_adaptor.h Mcp3204_adaptor.cpp Mcp3204_adaptor.h
  group Service
    ./: terminal_service.cpp terminal_service.h
  group System
    ./: System_main.cpp System_Manager.cpp System_Manager.h
  group Test
    ./: main.cpp testCLICommand.cpp testcmdadcdac.cpp testDin.cpp testlcd.cpp testLED.cpp testMCP3204.cpp testPowerSaving.cpp testRELAY.cpp testSerialIO.cpp testsysmainApp.cpp testTerminal_Service.cpp testTimer.cpp testWatchdog.cpp tsetDac7512.cpp
  group UserService
    ./: cli_command.cpp cli_command.h
  group Utils
    ./: split.cpp split.h split2.cpp sprintf.c
