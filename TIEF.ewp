# IAR project TIEF.ewp, settings and files
configuration Atmega164PA_Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x100
  General.SCRStackSize: 20
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-sf-n.h
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x90
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCDefines: NDEBUG; WATCHDOG_ENABLE
  ICCAVR.newCCIncludePaths: ./; $PROJ_DIR$
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\DLIB\
  prebuild: build_counter.exe
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm164pa.xcl
configuration Atmega164PA_Release (AVR)
  as the first configuration, except:
  ICCAVR.newCCIncludePaths: $PROJ_DIR$
  prebuild: D:\Work\IAR\Solar_test\build_counter.exe
configuration ATmega324P_Debug (AVR, debug)
  as the first configuration, except:
  General.SCCStackSize: 0x170
  General.SCRStackSize: 32
  General.LCNearHeapSize: 0x160
  ICCAVR.CCDefines: NDEBUG; xWATCHDOG_ENABLE
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm324p.xcl
configuration Test (AVR, debug)
  as the first configuration, except:
  General.SCCStackSize: 0x1c0
  General.SCRStackSize: 25
  General.LCNearHeapSize: 0x100
  ICCAVR.CCDefines: NDEBUG; xWATCHDOG_ENABLE
configuration ATmega324P_Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x170
  General.SCRStackSize: 32
  General.LCNearHeapSize: 0x160
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm324p.xcl
configuration ATmega128_Debug (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x2c0
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCNearHeapSize: 0x260
  ICCAVR.CCDefines: xNDEBUG; xWATCHDOG_ENABLE
  ICCAVR.newCCIncludePaths: ./; $PROJ_DIR$; TIEL_FrameWork/Basic_Component; TIEL_FrameWork/BSP/MC_E02SMB_v1_3; TIEL_FrameWork/Common; TIEL_FrameWork/Configuration; TIEL_FrameWork/CPU/AVR_Driver; TIEL_FrameWork/Driver_Interface; TIEL_FrameWork/Drivers; TIEL_FrameWork/Service; TIEL_FrameWork/System; TIEL_FrameWork/Test; TIEL_FrameWork/Utils; BUILD_COUNT
  prebuild: BUILD_COUNT\build_counter.exe
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
configuration ATmega128_Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x2c0
  General.SCRStackSize: 32
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dlAVR-3s-ec_mul-n.h
  General.LCNearHeapSize: 0x260
  ICCAVR.CCDefines: NDEBUG; xWATCHDOG_ENABLE
  ICCAVR.newCCIncludePaths: as above
  prebuild: BUILD_COUNT\build_counter.exe
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm128.xcl
  group APP/EBIO_APP
    APP/EBIO/: AutoOffTimer.cpp AutoOffTimer.h DacAdc.cpp DacAdc.h EBIOApplication.cpp EBIOApplication.h TerminalAdaptor.h
  group APP/EBIO_APP/UserService
    APP/EBIO/: cli_command.cpp cli_command.h
  group APP/LAB10_APP
    APP/LAB10/: displayadc.cpp displayadc.h lab10.cpp lab10.h
  group APP/LAB9_APP
    APP/LAB9/: lab9.cpp lab9.h stringprocessing.cpp stringprocessing.h
  group APP/Term_Project_APP
    APP/Term_Project/: CalClkFuncGen.cpp CalClkFuncGen.h Term_Project_s.cpp Term_Project_s.h
  group APP/TEST_APPS/CLCD_APP
    APP/TEST_APP/CLCD/: testCLCDApplication.cpp testCLCDApplication.h
  group APP/TEST_APPS/LED_APP
    APP/TEST_APP/LED/: testLEDApplication.cpp testLEDApplication.h
  group APP/TEST_APPS/SERIAL_APP
    APP/TEST_APP/SERIAL/: testSerialApplication.cpp testSerialApplication.h
  group APP/TEST_APPS/SW_APP
    APP/TEST_APP/SW/: testSWApplication.cpp testSWApplication.h
  group APP/USER_APP
    APP/User_App/: userApplication.cpp userApplication.h
  group AVR_Driver
    TIEL_FrameWork/CPU/AVR_Driver/: avr_adc.cpp avr_adc.h avr_common.cpp avr_common.h avr_nv_ram.cpp avr_pwm.cpp avr_pwm.h avr_sleep.cpp avr_spi.cpp avr_spi.h avr_timer.cpp avr_timer.h avr_uart.cpp avr_uart.h avr_WatchDog.cpp avr_watchdog.h
  group Basic_Component
    TIEL_FrameWork/Basic_Component/: adc.cpp adc.h BCComponentManager.cpp BCComponentManager.h DInTimerAdaptor.h dio.cpp dio.h led.cpp led.h Power_Manager.cpp pwm.cpp pwm.h serialIO.cpp serialIO.h StdConsole.cpp TimerManager.cpp TimerManager.h
  group BSP/EBIO_BSP_V1_0
    TIEL_FrameWork/BSP/EBIO_BSP_V1_0/: clcd_adaptor.cpp clcd_adaptor.h dac7512_adaptor.cpp dac7512_adaptor.h dio_adaptor.cpp dio_adaptor.h Mcp3204_adaptor.cpp mcp3204_adaptor.h
  group BSP/MC_E02SMB_v1_3
    TIEL_FrameWork/BSP/MC_E02SMB_v1_3/: clcd_adaptor.cpp clcd_adaptor.h dio_adaptor.cpp dio_adaptor.h
  group Common
    BUILD_COUNT/: build_count.h
    TIEL_FrameWork/Common/: ringbuffer.cpp ringbuffer.h shared_ptr.h type.cpp type.h util.h
  group Configuration
    TIEL_FrameWork/Configuration/: EBIODriverFactory.cpp MC_E02SMB_v1_3DriverFactory.cpp
  group doc
    ./: gpl-3.0.txt README.TXT
  group Driver_Interface
    TIEL_FrameWork/Driver_Interface/: DriverFactory.cpp DriverFactory.h ISpi.h
  group Drivers
    TIEL_FrameWork/Drivers/: clcd.cpp clcd.h dac7512.cpp dac7512.h mcp3204.cpp mcp3204.h
  group Service
    TIEL_FrameWork/Service/: ANSI200.cpp terminal_service.cpp terminal_service.h xmodem.cpp
  group System
    TIEL_FrameWork/System/: System_Info.cpp System_main.cpp System_Manager.cpp System_Manager.h
  group Test
    TIEL_FrameWork/Test/: main.cpp testCLICommand.cpp testcmdadcdac.cpp testDin.cpp testlcd.cpp testLED.cpp testMCP3204.cpp testPowerSaving.cpp testRELAY.cpp testSerialIO.cpp testsysmainApp.cpp testTerminal_Service.cpp testTimer.cpp testWatchdog.cpp tsetDac7512.c tsetDac7512.cpp
  group Utils
    TIEL_FrameWork/Utils/: binerytobcd.cpp split.cpp split.h split2.cpp sprintf.c
